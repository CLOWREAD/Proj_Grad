# Keil uVision project GraduationProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GraduationProject +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c ADC.c ADC.h DS18B20.h DS18B20.c
    ./SRC/: oled.c oled.h oledfont.h
